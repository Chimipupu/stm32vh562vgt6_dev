# Keil uVision project stm32h562vgt6_dev.uvprojx, settings and files
target stm32h562vgt6_dev (6240000::V6.24::ARMCLANG)
  device: STM32H562VGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: stm32h562vgt6_dev +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: UX_INCLUDE_USER_DEFINE_FILE,USE_HAL_DRIVER,STM32H562xx
  c include: ../Core/Inc;../USBX/App;../USBX/Target;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Middlewares/ST/usbx/common/core/inc;../Middlewares/ST/usbx/ports/generic/inc;../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../Middlewares/ST/usbx/common/usbx_device_classes/inc;../Drivers/CMSIS/Include;../Bsp;../App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h562xx.s
  group Application/User/Core
    ../Core/Src/: memorymap.c main.c gpio.c adc.c gpdma.c i2c.c icache.c usart.c rtc.c spi.c usb.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c app_usbx_device.c ux_device_cdc_acm.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/USBX/UX Device Controllers
    ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/Core System
    ../Middlewares/ST/usbx/common/core/src/: ux_system_tasks_run.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c ux_device_stack_tasks_run.c ux_device_stack_transfer_run.c
  group Middlewares/USBX/UX Device Class CDC ACM
    ../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write_with_callback.c ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_write_run.c
  group BSP
    ../Bsp/: board.c
  group MyApp
    ../App/: app_main.c
software components: CMSIS:CORE 4.3.0
